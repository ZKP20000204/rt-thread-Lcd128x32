# Keil uVision project n32g45xvl-stb.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARMLIBC, RT_USING_LIBC, N32G45X, __RTTHREAD__, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND
  c include: rt-thread\include;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m4;libraries\n32_drivers\config;rt-thread\components\libc\compilers\common\include;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\compilers\common\extension;applications;rt-thread\components\drivers\include;rt-thread\components\drivers\smp_call;.;rt-thread\components\drivers\include;libraries\N32G45x_Firmware_Library\n32g45x_std_periph_driver\inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;libraries\n32_drivers;libraries\N32G45x_Firmware_Library\CMSIS\device;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;board;libraries\N32G45x_Firmware_Library\CMSIS\core
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: lcd.c spi.c main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: dev_can.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c dac.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/rtc/: dev_rtc.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c
    rt-thread/components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    board/: board.c
    libraries/N32G45x_Firmware_Library/CMSIS/device/startup/: startup_n32g45x.s
    libraries/n32_drivers/: drv_adc.c drv_can.c drv_dac.c drv_gpio.c drv_hwtimer.c drv_rtc.c drv_spi.c drv_usart.c drv_wdt.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh.c shell.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/N32G45x_Firmware_Library/n32g45x_std_periph_driver/src/: n32g45x_spi.c n32g45x_tim.c n32g45x_can.c n32g45x_rcc.c n32g45x_dac.c n32g45x_wwdg.c n32g45x_iwdg.c n32g45x_exti.c misc.c n32g45x_usart.c n32g45x_gpio.c n32g45x_pwr.c n32g45x_i2c.c n32g45x_rtc.c n32g45x_adc.c
    libraries/N32G45x_Firmware_Library/CMSIS/device/: system_n32g45x.c
software components: CMSIS:CORE 5.4.0
