# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: N32G457VE Nations N32G457VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; N32G45X; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\n32_drivers; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\libraries\N32G45x_Firmware_Library\n32g45x_std_periph_driver\inc; ..\..\..\components\finsh; ..\..\..\components\libc\compilers\common\include; ..\..\..\libcpu\arm\cortex-m4; ..\libraries\n32_drivers\config; ..\..\..\include; ..\..\..\components\drivers\include; ..\libraries\N32G45x_Firmware_Library\CMSIS\device; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\posix\io\eventfd; .; applications; ..\libraries\N32G45x_Firmware_Library\CMSIS\core; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\compilers\common\extension; ..\..\..\libcpu\arm\common; ..\..\..\components\drivers\spi; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c dac.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/N32G45x_Firmware_Library/CMSIS/device/startup/: startup_n32g45x_EWARM.s
    board/: board.c
    ../libraries/n32_drivers/: drv_adc.c drv_can.c drv_dac.c drv_gpio.c drv_hwtimer.c drv_rtc.c drv_spi.c drv_usart.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    ../libraries/N32G45x_Firmware_Library/n32g45x_std_periph_driver/src/: n32g45x_pwr.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_exti.c n32g45x_can.c misc.c n32g45x_spi.c n32g45x_i2c.c n32g45x_adc.c n32g45x_rtc.c n32g45x_gpio.c n32g45x_iwdg.c n32g45x_dac.c n32g45x_tim.c n32g45x_rcc.c
    ../libraries/N32G45x_Firmware_Library/CMSIS/device/: system_n32g45x.c
